Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Capri-Dining Armchair - ver4.ifc
Time: 2024-12-10T14:13:30
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (3)
Name
 | Capri-Dining Armchair_0 - ObjectType: SketchupGroup
 | Capri-Dining Armchair_1 - ObjectType: SketchupGroup
 | Capri-Dining Armchair_2 - ObjectType: SketchupGroup
